# IAR project HIDDemo.ewp, settings and files
configuration CC2540USB HID Keyboard Central (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_HID=TRUE; USB_SETUP_MAX_NUMBER_OF_INTERFACES=3
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: CC2540USBLIB; ..\APPLICATION; ..\APPLICATION\USBLIBRARY; ..\APPLICATION\USBCLASS_HID; ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\Profiles\Roles
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
  group APP
    ../Application/: hidapp.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540USB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
    ../../../../Components/hal/target/CC2540USB/: hal_key.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2540EB/USB/class_hid
    ../Application/usbclass_hid/: usb_class_requests.c usb_firmware_library_config.c usb_hid.c usb_hid_descriptor.s51 usb_hid_hooks.c usb_hid_reports.c
    ../APPLICATION/USBCLASS_HID/: usb_class_requests.h usb_firmware_library_config.h usb_firmware_library_headers.h usb_hid.h usb_hid_reports.h
  group HAL/Target/CC2540EB/USB/library
    ../APPLICATION/USBLIBRARY/: usb_descriptor.h usb_descriptor_parser.h usb_framework.h usb_framework_structs.h usb_interrupt.h usb_reg.h usb_standard_requests.h usb_suspend.h
    ../Application/usblibrary/: usb_descriptor_parser.c usb_framework.c usb_standard_requests.c
  group HAL/Target/CC2540EB/USB/library/cc2540
    CC2540USBLIB/: usb_board_cfg.h
    cc2540usblib/: usb_interrupt.c usb_suspend.c
  group LIB
    ../../Libraries/CC2540DB/bin/: ble_single_chip_master_pm_off.lib
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Roles/: central.c central.h gapbondmgr.c gapbondmgr.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
  group TOOLS
    ../../config/: config.cfg config_master.cfg config_slave.cfg
    ../../common/cc2540/: lnk51ew_cc2530b_banked_rom_data.xcl lnk_banked_rom_data.xcl OnBoard.c OnBoard.h
